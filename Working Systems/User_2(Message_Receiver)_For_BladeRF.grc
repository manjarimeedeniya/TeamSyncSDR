options:
  parameters:
    author: User
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Communicatio Design Project
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.6'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset/2
    noise_voltage: noise_volt/3
    seed: '0'
    taps: '[1+0j, 0.3+0.1j, 0.1-0.2j]'
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset/2
    noise_voltage: noise_volt/3
    seed: '0'
    taps: '[1+0j, 0.3+0.1j, 0.1-0.2j]'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {state: disabled}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time

      # Map your source IDs to TDMA slot numbers
      USER_SLOT_MAP = {
          0x01: 0,  # User A
          0x02: 1,  # User B
          0x03: 2,  # User C
          0x04: 3,  # User D
          0x05: 4   # User E
      }

      class tdma_scheduler(gr.basic_block):
          """
          TDMA Scheduler Block
          Reads the first byte of a packet (src_id) and gates transmission 
          based on the wall-clock time slot.
          """

          def __init__(self, slot_len_ms=1.5, num_slots=4):
              gr.basic_block.__init__(
                  self,
                  name="tdma_scheduler_auto",
                  in_sig=[np.uint8],   # Input: Bytes (Orange)
                  out_sig=[np.uint8]   # Output: Bytes (Orange)
              )

              self.slot_len = float(slot_len_ms) / 1000.0
              self.num_slots = int(num_slots)
              self.frame_len = self.slot_len * self.num_slots
              self.time_offset = 0.0

              # Store the slot number of the current packet
              self.current_slot = None

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              
              # SAFETY: Calculate 'n' based on the smaller buffer to prevent overflows
              n = min(len(inp), len(out))
              
              if n == 0:
                  return 0

              # Logic: Check user ID from the first byte of the chunk
              # Note: The code currently attempts to read index 8 (inp[8])
              if n > 8: # Ensure the buffer is large enough for index 8
                  src_id = int(inp[8])
                  
                  # --- DEBUG PRINT COMMAND INSERTED HERE ---
                  if src_id in USER_SLOT_MAP:
                      print(f"[TDMA] Reading Source ID: 0x{src_id:02X} -> Slot {USER_SLOT_MAP[src_id]}")
                  else:
                      print(f"[TDMA] Reading Source ID: 0x{src_id:02X} (Unmapped)")
                  # ----------------------------------------
                  
                  # Only update slot if the ID is found in our map
                  if src_id in USER_SLOT_MAP:
                      self.current_slot = USER_SLOT_MAP[src_id]

              # Compute current time in the TDMA frame
              # (Using system time for basic synchronization)
              now = (time.time() + self.time_offset) % self.frame_len
      	
              # Gating Logic
              if self.current_slot is not None:
                  slot_start = self.current_slot * self.slot_len
                  slot_end = slot_start + self.slot_len

                  if slot_start <= now < slot_end:
                      out[:n] = inp[:n]  # Transmit data
                  else:
                      out[:n] = 0        # Block data (send zeros)
              else:
                  # If no user ID is recognized yet, block data
                  out[:n] = 0

              # Tell GNU Radio we consumed 'n' items
              self.consume(0, n)
              return n
    num_slots: '4'
    slot_len_ms: '1.5'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, target_file="output.txt", append_mode=False):
              gr.basic_block.__init__(
                  self,
                  name="pdu_to_file_sink",
                  in_sig=[],
                  out_sig=[]
              )

              # Output file path
              self.file_target = target_file
              # Append mode flag: True = append, False = overwrite
              self.do_append = append_mode

              # Input port for PDUs
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.write_pdu_to_file)

              # Clear file at startup if not appending
              if not self.do_append:
                  with open(self.file_target, "wb"):
                      pass  # Just open and close to clear the file

          def write_pdu_to_file(self, msg):
              """Save the payload of an incoming PDU to disk"""
              header_info = pmt.car(msg)
              payload_pmt = pmt.cdr(msg)

              # Only process valid u8vector PDUs
              if pmt.is_u8vector(payload_pmt):
                  payload_bytes = bytes(pmt.u8vector_elements(payload_pmt))

                  # Write payload to file in append mode
                  with open(self.file_target, "ab") as file_handle:
                      file_handle.write(payload_bytes)

                  # Optional log for debugging
                  print(f"[PDU Writer] Wrote {len(payload_bytes)} bytes to '{self.file_target}'")
    append_mode: 'False'
    target_file: r"output.txt"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import numpy as np

      class pdu_garbage_injector(gr.basic_block):
          """
          Sends a randomly generated 256-byte garbage PDU once,
          then forwards all normal PDUs afterwards.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="pdu_garbage_injector",
                  in_sig=None,
                  out_sig=None,
              )

              # Register PDU ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              # --- Generate 256 random bytes (0–255 each) ---
              garbage = np.random.randint(0, 256, 256, dtype=np.uint8)

              # Convert to PMT PDU
              self.garbage_pdu = pmt.cons(
                  pmt.PMT_NIL,
                  pmt.init_u8vector(len(garbage), garbage)
              )

              self.sent = False

              # Send garbage packet immediately at startup
              self.message_port_pub(pmt.intern("out"), self.garbage_pdu)
              self.sent = True

              # Install handler for input PDUs
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              """
              Forward all incoming PDUs after garbage was sent.
              """
              if not pmt.is_pair(msg):
                  return

              # Forward incoming PDU normally
              self.message_port_pub(pmt.intern("out"), msg)
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import threading
      import time
      from gnuradio import gr

      USER_IDS = {
          "A": 0x01,
          "B": 0x02,
          "C": 0x03,
          "D": 0x04,
          "E": 0x05
      }

      class blk(gr.basic_block):
          def __init__(self, input_file="", send_interval=1.0, packet_limit=32,
                       sender_id=0x01, receiver_id=0x02, max_attempts=100):
              gr.basic_block.__init__(
                  self,
                  name="file_to_pdu_sender",
                  in_sig=[],
                  out_sig=[]
              )

              # Parameters
              self.source_file = input_file
              self.interval_sec = float(send_interval)
              self.max_packet_len = int(packet_limit)
              self.node_src_id = sender_id
              self.node_dst_id = receiver_id
              self.max_attempts = int(max_attempts)

              # Ports
              self.message_port_register_out(pmt.intern("pdus"))
              self.message_port_register_in(pmt.intern("ack_bits"))
              self.set_msg_handler(pmt.intern("ack_bits"), self.handle_ack)

              # Threading & ACK tracking
              self.stop_event = threading.Event()
              self.ack_event = threading.Event()
              self.expected_ack = None
              self.lock = threading.Lock()

              # bookkeeping
              self.acked_packets = set()
              self.skipped_packets = []
              self.total_sent_packets = 0

              # Sender thread
              self.sender_thread = threading.Thread(target=self._send_loop)
              self.sender_thread.daemon = True
              self._thread_started = False

          def start(self):
              # Ensure we only start the sender thread once
              self.stop_event.clear()
              if not self._thread_started:
                  self.sender_thread.start()
                  self._thread_started = True
              # return value follows GNU Radio convention
              try:
                  return super().start()
              except Exception:
                  return True

          def stop(self):
              self.stop_event.set()
              self.ack_event.set()  # unblock waiting
              if self._thread_started and self.sender_thread.is_alive():
                  self.sender_thread.join(timeout=1.0)
              try:
                  return super().stop()
              except Exception:
                  return True

          def _send_loop(self):
              try:
                  with open(self.source_file, 'rb') as f:
                      raw_data = f.read()
              except Exception as e:
                  print(f"[PDU Sender] Failed to read file: {str(e)}")
                  return

              # Split into packets (3 bytes reserved for header)
              chunks = [
                  raw_data[i:i + self.max_packet_len - 3]
                  for i in range(0, len(raw_data), self.max_packet_len - 3)
              ]

              pkt_num = 1  # Start numbering at 1

              for chunk in chunks:
                  if self.stop_event.is_set():
                      break

                  full_packet = bytes([self.node_src_id, self.node_dst_id, pkt_num]) + chunk
                  pdu_payload = pmt.init_u8vector(len(full_packet), list(full_packet))
                  pdu_msg = pmt.cons(pmt.make_dict(), pdu_payload)

                  # prepare to wait for ACK for this packet
                  with self.lock:
                      self.expected_ack = pkt_num
                      self.ack_event.clear()

                  attempt = 0
                  got_ack = False

                  # Attempt up to max_attempts
                  while not self.stop_event.is_set() and attempt < self.max_attempts:
                      self.message_port_pub(pmt.intern("pdus"), pdu_msg)
                      self.total_sent_packets += 1
                      print(f"[PDU Sender] Packet #{pkt_num:02X} sent (try {attempt+1})")

                      # Wait for ACK (sets by handler)
                      ack_received = self.ack_event.wait(timeout=self.interval_sec)

                      if ack_received:
                          # verify that the handler matched the expected ack (handler only sets when match)
                          with self.lock:
                              if pkt_num in self.acked_packets:
                                  got_ack = True
                          if got_ack:
                              break
                          # If ack_event was set but ack didn't correspond, continue retrying
                      else:
                          # timeout
                          attempt += 1
                          print(f"[PDU Sender] Timeout waiting for ACK for packet #{pkt_num:02X} (attempt {attempt})")

                  if got_ack:
                      print(f"[PDU Sender] Confirmed ACK for packet #{pkt_num:02X}")
                  else:
                      # Reached max_attempts without correct ACK -> skip this packet and continue
                      print(f"[PDU Sender] No ACK after {self.max_attempts} tries for packet #{pkt_num:02X}, skipping...")
                      self.skipped_packets.append(pkt_num)
                      # ensure ack_event is cleared before moving on
                      with self.lock:
                          self.ack_event.clear()
                          # Note: expected_ack will be overwritten for next packet

                  # increment packet number (wrap 1..255)
                  pkt_num = (pkt_num + 1) & 0xFF
                  if pkt_num == 0x00:
                      pkt_num = 0x01

              # finished sending (either end of file or stop event)
              print("[PDU Sender] Send loop finished.")
              print(f"  Total PDUs transmitted attempts: {self.total_sent_packets}")
              print(f"  ACKed packets (count): {len(self.acked_packets)} -> {sorted(self.acked_packets)}")
              print(f"  Skipped packets (count): {len(self.skipped_packets)} -> {self.skipped_packets}")

          def handle_ack(self, msg):
              """Process incoming ACK"""
              # msg might be a PMT pair (meta, u8vector) or already the u8vector depending on sender
              try:
                  if pmt.is_pair(msg):
                      ack_data = pmt.cdr(msg)
                  else:
                      ack_data = msg
              except Exception:
                  print("[PDU Sender] ACK handler received unexpected PMT message")
                  return

              if not pmt.is_u8vector(ack_data):
                  print("[PDU Sender] Invalid ACK format (not u8vector)")
                  return

              ack_bytes = bytearray(pmt.u8vector_elements(ack_data))
              print(f"[PDU Sender] Raw ACK received: {list(ack_bytes)}")  # DEBUG

              if len(ack_bytes) < 2 or ack_bytes[0] != 0xAA:
                  print("[PDU Sender] Invalid ACK header or too short")
                  return

              ack_num = ack_bytes[1]
              with self.lock:
                  # Only set the event if ACK matches the expected packet number
                  if ack_num == self.expected_ack:
                      print(f"[PDU Sender] ACK matches expected packet #{ack_num:02X} -- setting event")
                      self.acked_packets.add(ack_num)
                      self.ack_event.set()
                  else:
                      # ACK for some other packet (maybe a late ACK) -> ignore
                      print(f"[PDU Sender] ACK for packet #{ack_num:02X} does not match expected #{self.expected_ack:02X}, ignoring")
    input_file: r"/home/manjarimanesha/input.txt"
    max_attempts: '1000'
    packet_limit: '32'
    receiver_id: '2'
    send_interval: '0.01'
    sender_id: '1'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      USER_IDS = {
          "A": 0x01,
          "B": 0x02,
          "C": 0x03,
          "D": 0x04,
          "E": 0x05
      }

      class blk(gr.basic_block):
          def __init__(self, node_id=0x03):
              gr.basic_block.__init__(
                  self,
                  name="addressed_pdu_filter",
                  in_sig=[],
                  out_sig=[]
              )

              # Receiver’s ID
              self.receiver_id = node_id

              # Ports
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.message_port_register_out(pmt.intern("ack_out"))

              self.set_msg_handler(pmt.intern("pdus_in"), self.handle_incoming_pdu)

              # Stop-and-Wait: expected packet number
              self.expected_pkt_num = 1

          def handle_incoming_pdu(self, msg):
              pdu_payload = pmt.cdr(msg)

              if not pmt.is_u8vector(pdu_payload):
                  print("[Receiver] Invalid PDU")
                  return

              packet_bytes = bytearray(pmt.u8vector_elements(pdu_payload))
              if len(packet_bytes) < 3:
                  print("[Receiver] Too short PDU")
                  return

              src_id, dest_id, pkt_num = packet_bytes[0], packet_bytes[1], packet_bytes[2]

              if dest_id != self.receiver_id:
                  print(f"[Receiver] Packet not for me (dest={dest_id:02X})")
                  return

              if pkt_num == self.expected_pkt_num:
                  # Correct → deliver payload
                  payload_only = packet_bytes[3:]
                  payload_pmt = pmt.init_u8vector(len(payload_only), payload_only)
                  forward_msg = pmt.cons(pmt.make_dict(), payload_pmt)
                  self.message_port_pub(pmt.intern("pdus_out"), forward_msg)

                  print(f"[Receiver] Accepted packet #{pkt_num:02X}")

                  # Update expected
                  self.expected_pkt_num = (self.expected_pkt_num + 1) & 0xFF
                  if self.expected_pkt_num == 0x00:
                      self.expected_pkt_num = 0x01
              else:
                  print(f"[Receiver] Unexpected packet #{pkt_num:02X}, expecting #{self.expected_pkt_num:02X}")

              # Always ACK last valid packet
              ack_num = pkt_num if pkt_num == (self.expected_pkt_num - 1) else (self.expected_pkt_num - 1) & 0xFF
              if ack_num == 0x00:
                  ack_num = 0xFF

              ack_bytes = bytes([0xAA, ack_num])
              ack_msg = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(ack_bytes), list(ack_bytes)))

              # Send ACK multiple times for reliability
              for _ in range(5):
                  self.message_port_pub(pmt.intern("ack_out"), ack_msg)

              print(f"[Receiver] ACK sent for packet #{ack_num:02X}")
    node_id: '2'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_garbage_remover(gr.basic_block):
          """
          Drops the first incoming PDU of 256 bytes (garbage packet), 
          then passes everything else.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="pdu_garbage_remover",
                  in_sig=None,
                  out_sig=None,
              )

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.dropped = False  # drop only first PDU

              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return

              meta = pmt.car(msg)
              vec = pmt.cdr(msg)
              length = pmt.length(vec)

              # Drop only first 256-byte PDU
              if not self.dropped and length == 256:
                  self.dropped = True
                  return  # do not output

              # Forward everything else
              self.message_port_pub(pmt.intern("out"), msg)
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import numpy as np


      class pdu_padder(gr.basic_block):
          """
          Appends pad_len bytes with value pattern_byte to the end of each PDU:

              [DATA] -> [DATA | PAD...]

          DATA here is [HEADER | PAYLOAD | CRC] once we rewire.
          """

          def __init__(self, pad_len=256, pattern_byte=0x55):
              gr.basic_block.__init__(self,
                                      name="pdu_padder",
                                      in_sig=None,
                                      out_sig=None)

              self.pad_len = int(pad_len)
              self.pattern_byte = int(pattern_byte) & 0xFF
              self.pad = np.full(self.pad_len, self.pattern_byte, dtype=np.uint8)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def _update_length_meta(self, meta, new_len):
              if not pmt.is_dict(meta):
                  return meta
              for key_str in ["packet_len", "pdu_len", "length"]:
                  key = pmt.intern(key_str)
                  if pmt.dict_has_key(meta, key):
                      meta = pmt.dict_add(meta, key, pmt.from_long(new_len))
              return meta

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or self.pad_len <= 0:
                  return self.message_port_pub(pmt.intern("out"), msg)

              meta = pmt.car(msg)
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return self.message_port_pub(pmt.intern("out"), msg)

              data = np.frombuffer(bytes(pmt.u8vector_elements(vec)), dtype=np.uint8)
              new_data = np.concatenate((data, self.pad))

              meta = self._update_length_meta(meta, len(new_data))
              new_vec = pmt.init_u8vector(len(new_data), new_data.tolist())
              new_msg = pmt.cons(meta, new_vec)
              self.message_port_pub(pmt.intern("out"), new_msg)
    pad_len: '256'
    pattern_byte: '0x55'
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import numpy as np


      class pdu_padder(gr.basic_block):
          """
          Appends pad_len bytes with value pattern_byte to the end of each PDU:

              [DATA] -> [DATA | PAD...]

          DATA here is [HEADER | PAYLOAD | CRC] once we rewire.
          """

          def __init__(self, pad_len=256, pattern_byte=0x55):
              gr.basic_block.__init__(self,
                                      name="pdu_padder",
                                      in_sig=None,
                                      out_sig=None)

              self.pad_len = int(pad_len)
              self.pattern_byte = int(pattern_byte) & 0xFF
              self.pad = np.full(self.pad_len, self.pattern_byte, dtype=np.uint8)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def _update_length_meta(self, meta, new_len):
              if not pmt.is_dict(meta):
                  return meta
              for key_str in ["packet_len", "pdu_len", "length"]:
                  key = pmt.intern(key_str)
                  if pmt.dict_has_key(meta, key):
                      meta = pmt.dict_add(meta, key, pmt.from_long(new_len))
              return meta

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or self.pad_len <= 0:
                  return self.message_port_pub(pmt.intern("out"), msg)

              meta = pmt.car(msg)
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return self.message_port_pub(pmt.intern("out"), msg)

              data = np.frombuffer(bytes(pmt.u8vector_elements(vec)), dtype=np.uint8)
              new_data = np.concatenate((data, self.pad))

              meta = self._update_length_meta(meta, len(new_data))
              new_vec = pmt.init_u8vector(len(new_data), new_data.tolist())
              new_msg = pmt.cons(meta, new_vec)
              self.message_port_pub(pmt.intern("out"), new_msg)
    pad_len: '128'
    pattern_byte: '0x55'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import numpy as np


      class pdu_unpadder(gr.basic_block):
          """
          Removes pad_len bytes from the *end* of each PDU:

              [DATA | PAD...] -> [DATA]

          Must use the same pad_len as pdu_padder.
          """

          def __init__(self, pad_len=256):
              gr.basic_block.__init__(self,
                                      name="pdu_unpadder",
                                      in_sig=None,
                                      out_sig=None)

              self.pad_len = int(pad_len)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def _update_length_meta(self, meta, new_len):
              if not pmt.is_dict(meta):
                  return meta
              for key_str in ["packet_len", "pdu_len", "length"]:
                  key = pmt.intern(key_str)
                  if pmt.dict_has_key(meta, key):
                      meta = pmt.dict_add(meta, key, pmt.from_long(new_len))
              return meta

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or self.pad_len <= 0:
                  return self.message_port_pub(pmt.intern("out"), msg)

              meta = pmt.car(msg)
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return self.message_port_pub(pmt.intern("out"), msg)

              data = np.frombuffer(bytes(pmt.u8vector_elements(vec)), dtype=np.uint8)
              length = len(data)

              if length <= self.pad_len:
                  # Too short to safely strip pad – forward unchanged
                  return self.message_port_pub(pmt.intern("out"), msg)

              new_data = data[: length - self.pad_len]

              meta = self._update_length_meta(meta, len(new_data))
              new_vec = pmt.init_u8vector(len(new_data), new_data.tolist())
              new_msg = pmt.cons(meta, new_vec)
              self.message_port_pub(pmt.intern("out"), new_msg)
    pad_len: '256'
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import numpy as np


      class pdu_unpadder(gr.basic_block):
          """
          Removes pad_len bytes from the *end* of each PDU:

              [DATA | PAD...] -> [DATA]

          Must use the same pad_len as pdu_padder.
          """

          def __init__(self, pad_len=256):
              gr.basic_block.__init__(self,
                                      name="pdu_unpadder",
                                      in_sig=None,
                                      out_sig=None)

              self.pad_len = int(pad_len)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def _update_length_meta(self, meta, new_len):
              if not pmt.is_dict(meta):
                  return meta
              for key_str in ["packet_len", "pdu_len", "length"]:
                  key = pmt.intern(key_str)
                  if pmt.dict_has_key(meta, key):
                      meta = pmt.dict_add(meta, key, pmt.from_long(new_len))
              return meta

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or self.pad_len <= 0:
                  return self.message_port_pub(pmt.intern("out"), msg)

              meta = pmt.car(msg)
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return self.message_port_pub(pmt.intern("out"), msg)

              data = np.frombuffer(bytes(pmt.u8vector_elements(vec)), dtype=np.uint8)
              length = len(data)

              if length <= self.pad_len:
                  # Too short to safely strip pad – forward unchanged
                  return self.message_port_pub(pmt.intern("out"), msg)

              new_data = data[: length - self.pad_len]

              meta = self._update_length_meta(meta, len(new_data))
              new_vec = pmt.init_u8vector(len(new_data), new_data.tolist())
              new_msg = pmt.cons(meta, new_vec)
              self.message_port_pub(pmt.intern("out"), new_msg)
    pad_len: '128'
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    label2: ''
    name: ''
    nconnections: '2'
    size: '64'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: correlate output
    size: '256'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: correlate output
    size: '256'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    name: TDMA_Output
    size: '256'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 900e6
    gain: '50.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 900e6
    gain: '50.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: 900e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    center_freq: 900e6
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: pkt_out_1
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: CONS_IN
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: CONS_OUT
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: ack_out
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: r3
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: r2
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: ack_out
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: CONS_OUT
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: pkt_out_1
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: CONS_IN
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: r3
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_1, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_3, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', virtual_sink_1_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_crc_append_0, out, epy_block_4, in]
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_check_0, ok, epy_block_2, pdus_in]
- [digital_crc_check_0_0, ok, virtual_sink_5, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0_0, '0']
- [digital_linear_equalizer_0_0, '0', virtual_sink_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [epy_block_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [epy_block_0, '0', digital_constellation_modulator_0, '0']
- [epy_block_1, out, digital_crc_append_0, in]
- [epy_block_1_0, pdus, epy_block_1, in]
- [epy_block_2, ack_out, virtual_sink_4, '0']
- [epy_block_2, pdus_out, epy_block_3, in]
- [epy_block_3, out, epy_block_0_0, pdus]
- [epy_block_4, out, digital_protocol_formatter_async_0, in]
- [epy_block_4_0, out, digital_crc_append_0_0, in]
- [epy_block_5, out, digital_crc_check_0, in]
- [epy_block_5_0, out, digital_crc_check_0_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_5, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_block_5_0, in]
- [soapy_bladerf_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [soapy_bladerf_source_0_0, '0', channels_channel_model_0_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', virtual_sink_2, '0']
- [virtual_source_0_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [virtual_source_0_1, '0', epy_block_4_0, in]
- [virtual_source_0_1_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_1, '0', blocks_uchar_to_float_0_0, '0']
- [virtual_source_1, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_1_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_1_1, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_3, '0', epy_block_1_0, ack_bits]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
